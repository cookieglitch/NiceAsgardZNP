<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HAL Helper.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Program ZNP.ewp</path>
  </project>
  <batchBuild/>
</workspace>


